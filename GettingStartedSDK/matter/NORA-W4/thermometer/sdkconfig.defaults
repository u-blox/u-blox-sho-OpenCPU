## zephyr/boards/u-blox/ubx_evkannab4/board.yml
```yaml
board:
  name: ubx_evkannab4
  full_name: EVK-ANNA-B4
  vendor: u-blox
  socs:
  - name: nrf52833
```
